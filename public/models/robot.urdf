Commit message: URDF

File: public/models/robot.urdf (robot description, URDF)
Before this commit: robot industrial_robot, 8 links, 7 joints
Joints:
- removed joint end_effector_joint
